Commit message: Fix some rviz stuff

File: code/hli/ros/src/aauship/urdf/aauship.urdf (robot description, URDF)
Before this commit: robot myfirst, 1 links, 0 joints
Links:
- removed link base_link
- added link boat_link; visual mesh filename=package://aauship/urdf/aauship.dae scale=0.1 0.1 0.1
